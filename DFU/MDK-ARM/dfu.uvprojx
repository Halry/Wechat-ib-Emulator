# Keil uVision project dfu.uvprojx, settings and files
target dfu (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dfu
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Middlewares\ST\STM32_Cryptographic\Inc;..\Middlewares\ST\STM32_Cryptographic\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: usbd_conf.c stm32f1xx_it.c stm32f1xx_hal_msp.c main.c usbd_cdc_if.c usbd_desc.c usb_device.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pcd.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Crypto
    ../Middlewares/ST/STM32_Cryptographic/Lib/: STM32CryptographicV3.0.0_CM3_KEIL_slsm1elfspf.lib
software components: CMSIS:CORE 5.0.2
